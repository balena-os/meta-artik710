COMPATIBLE_MACHINE = "(artik5|artik10|artik710)"
