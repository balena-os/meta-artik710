FILESEXTRAPATHS_prepend_artik710 := "${THISDIR}/files:"

SRC_URI_append_artik710 = " file://BCM4354_003.001.012.0301.0000_Samsung_Artik_TEST_ONLY.hcd"

COMPATIBLE_MACHINE = "(artik5|artik10|artik710)"
